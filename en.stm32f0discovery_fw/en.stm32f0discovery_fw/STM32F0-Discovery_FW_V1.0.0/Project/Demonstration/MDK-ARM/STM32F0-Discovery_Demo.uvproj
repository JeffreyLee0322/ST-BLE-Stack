# Keil uVision project STM32F0-Discovery_Demo.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Demo
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX STINGRAY_DISCOVERY
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32F0-Discovery;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\BLE_Stack\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: system_stm32f0xx.c main.c stm32f0xx_it.c cms_spi.c cms_24g.c cms_24g2.c
  group STM32F0-Discovery
    ../../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_syscfg.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c
  group MDK-ARM
    ../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group HAL
    ../BLE_Stack/src/: hal_ble.c hal_spi.c
  group System
    ../BLE_Stack/src/: sys_delay.c
